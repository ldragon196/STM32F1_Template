# Keil uVision project STM32F1_Template.uvprojx, settings and files
target STM32F1_Template (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F10x_Common +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: ..\Libraries\CMSIS\CM3\CoreSupport;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\Libraries\STM32F10x_StdPeriph_Driver;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Libraries\STM32F10x_StdPeriph_Driver\src;..\Source
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group App
    ../Source/App/: Main.c
    ../Source/: Config.h Board.c Board.h
  group Hard
    ../Source/Hard/Uart/: Uart.c Uart.h
    ../Source/Hard/Event/: Event.c Event.h
    ../Source/Hard/GPIO/: GPIO.c GPIO.h
    ../Source/Hard/WDG/: WDG.c WDG.h
    ../Source/Hard/I2C/: I2C.c I2C.h
    ../Source/Hard/Timer/: Timer.c Timer.h
  group Utility
    ../Source/Utility/: Utility.h
    ../Source/Utility/Debug/: Debug.c Debug.h
  group Components
    ../Source/Components/VL53L0X/: VL53L0X.c VL53L0X.h
  group STM32F10x_StdPeriph_Driver
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_exti.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_spi.c stm32f10x_i2c.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_iwdg.c stm32f10x_wwdg.c stm32f10x_flash.c stm32f10x_dac.c
    ../Libraries/STM32F10x_StdPeriph_Driver/: stm32f10x_conf.h
  group CMSIS
    ../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group Startup
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
